Commit message: stl file

File: manipulator_sim/urdf/6dofarm.urdf (robot description, URDF)
Before this commit: robot 6dofarm, 8 links, 7 joints
Links:
- link link1: geometry collision box size=0.08 0.08 0.15; visual box size=0.08 0.08 0.15
